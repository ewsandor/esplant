# Repository ewsandor/esplant

File README.md:

# ESPlant

Ed Sandor's Plant Monitor based on an ESP 32 processor

## KiCad design pcb/ESPlant.kicad_pcb

Parts:
C1, C3: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C2, C4: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1: LL4148; D_MiniMELF
J1: Power; PinHeader_1x02_P2.54mm_Vertical
J2: TAG; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J3: PUMP; PinHeader_1x04_P2.54mm_Vertical
J4: Soil Moisture; PinHeader_1x03_P2.54mm_Vertical
Q1: MMBT2222ALT1G; SOT-23_Handsoldering
Q2: Pump Driver; TRANS_RFP30N06LE
R1: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2: 1K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3: 33k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4: 51k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5: 10K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: R_PHOTO; R_LDR_5.1x4.3mm_P3.4mm_Vertical
R7: 100K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R8, R9: 4.7K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R10: 0; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: ESP32-WROOM-32
U2: Si7021-A20; DFN-6-1EP_3x3mm_P1mm_EP1.5x2.4mm
U3: LD1117S33TR_SOT223; SOT-223-3_TabPin2

Connections:
+3V3: C2.1, C3.1, J2.2, J4.1, R1.1, R6.1, R8.2, R9.1, U1.2 (VDD), U2.5 (VDD), U3.2 (VO)
+BATT: C4.1, J1.1, R3.1, R10.1, U3.3 (VI)
AMBL_ANALOG: R6.2, R7.1, U1.7 (IO35)
BATT_ANALOG: R3.2, R4.1, U1.9 (IO33)
EN: C1.1, J2.1, R1.2, U1.3 (EN)
GNDREF: C1.2, C2.2, C3.2, C4.2, J1.2, J2.4, J3.2, Q1.2 (E), Q2.3 (S), R4.2, R5.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U3.1 (GND)
IO0: J2.6, U1.25 (IO0)
unnamed: Q1.1 (B), R2.1
unnamed: Q1.3 (C), U2.2 (GND)
PUMP+: D1.1 (K), J3.1, J3.3, R10.2
PUMP-: D1.2 (A), J3.4, Q2.2 (D)
PUMP_EN: Q2.1 (G), R5.2, U1.8 (IO32)
RX0: J2.5, U1.34 (RXD0/IO3)
SCL: R9.2, U1.36 (IO22), U2.6 (SCL)
SDA: R8.1, U1.33 (IO21), U2.1 (SDA)
SENSOR_EN: J4.3, R7.2, U1.11 (IO26)
SOIL_ANALOG: J4.2, U1.6 (IO34)
TH_SENSOR_EN: R2.2, U1.12 (IO27)
TX0: J2.3, U1.35 (TXD0/IO1)

Notes on the sheet:
Temperature and Humidity Sensor
Power Regulator
Pump Interface
R10 optional to tie pump power supply to main power supply
Power Connector
Programmer Interface
Pump Driver Circuit
I2C Pullup Resistors

Board: 2 copper layers, 43.0 x 23.0 mm, 24 parts (17 on the bottom side), 19 nets.

## KiCad design ESPlant.kicad_pcb

Parts:
C1: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C2, C3: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: LL4148; D_MiniMELF
J1: TAG; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J2: PUMP; PinHeader_1x04_P2.54mm_Vertical
J3: Soil Moisture; PinHeader_1x03_P2.54mm_Vertical
J4: Power; PinHeader_1x02_P2.54mm_Vertical
Q2: Q_NPN_BCE; SOT-23_Handsoldering
Q3: Pump Driver; TRANS_RFP30N06LE
R1: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2, R10: 4.7K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3, R4: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5, R8: 1K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: R_PHOTO; R_LDR_5.1x4.3mm_P3.4mm_Vertical
R7: 100K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R9: 0; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: ESP32-WROOM-32
U2: LD1117S33TR_SOT223; SOT-223-3_TabPin2
U3: Si7021-A20; DFN-6-1EP_3x3mm_P1mm_EP1.5x2.4mm

Connections:
+3V3: C1.1, C2.1, J1.2, J3.1, R1.1, R2.2, R6.1, R10.1, U1.2 (VDD), U2.2 (VO), U3.5 (VDD)
+BATT: J4.2, R3.1, R9.1, U2.3 (VI)
AMBL_ANALOG: R6.2, R7.1, U1.7 (IO35)
BATT_ANALOG: R3.2, R4.1, U1.9 (IO33)
EN: C3.1, J1.1, R1.2, U1.3 (EN)
GNDREF: C1.2, C2.2, C3.2, J1.4, J2.2, J4.1, Q2.3, Q3.3 (S), R4.2, R8.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.1 (GND), U3.2 (GND)
IO0: J1.6, U1.25 (IO0)
unnamed: J3.3, Q2.2, R7.2
unnamed: Q2.1, R5.1
PUMP+: D2.1 (K), J2.1, J2.3, R9.2
PUMP-: D2.2 (A), J2.4, Q3.2 (D)
Pump_En: Q3.1 (G), R8.2, U1.12 (IO27)
RX0: J1.5, U1.34 (RXD0/IO3)
SCL: R10.2, U1.36 (IO22), U3.6 (SCL)
SDA: R2.1, U1.33 (IO21), U3.1 (SDA)
SENSOR_EN: R5.2, U1.8 (IO32)
SOIL_ANALOG: J3.2, U1.6 (IO34)
TX0: J1.3, U1.35 (TXD0/IO1)

Board: 2 copper layers, 69.0 x 24.0 mm, 23 parts (0 on the bottom side), 18 nets.

## Commit log

2020-02-29 Add LICENSE
2020-02-29 Initial checkin of project files as is
2020-02-29 Moving kicad files to PCB directory
2020-03-01 Updating sensor enable/disable schematic. FIrst attempt at board layout
2020-03-07 Increase with of pump traces to support 1A
2020-03-08 Official revision 0.1! Adding revision info and logo to PCB
2020-03-10 PCB Revision 0.2 fixing Q1 footprint from NPN BCE to BEC to match more common parts. Minor routing revisions
2020-03-10 Silkscreen cleanup
2020-03-29 Initial ESPlant Arduino based software. Updated battery voltage divider values in schematic.
2020-08-11 Flipping batter positive and negative pins and added '+' symbol to resolve ambiguity during assembly
